# Keil uVision project RTC_Demo.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F407ZGTx STMicroelectronics
  pack: Keil.STM32F4xx_DFP.2.16.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x10000000,0x00010000) IROM(0x08000000,0x00100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: RTC_Demo +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\MyCode;.\SYSTEM;.\FATFS\exfuns;.\FATFS\src;.\HARDWARE;.\MALLOC;.\TEXT;.\USMART;.\APP;.\AUDIOCODEC;.\XMRAM;.\FATFS\doc;.\ATK-RM04
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x10000000 size 0x10000
  group :STM32CubeMX:Common Sources
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Src/: main.c stm32f4xx_it.c
    ./RTE/Device/STM32F407ZGTx/STCubeGenerated/Inc/: stm32f4xx_it.h
  group MyCode
    ./MyCode/: RTC.c RTC.h font.h lcd.c lcd.h Menu.c Menu.h VOICE.c VOICE.h beep.c beep.h ADC.c ADC.h dac_wave.c dac_wave.h dackey.c dackey.h eeprom.c eeprom.h tetrisGame.c tetrisGame.h
  group SYSTEM
    ./SYSTEM/: delay.c delay.h sys.c sys.h usart.c usart.h
  group FATFS
    ./FATFS/src/: diskio.c ff.c
    ./FATFS/exfuns/: exfuns.c fattester.c mycc936.c
  group HARDWARE
    ./HARDWARE/: sdio_sdcard.c sdio_sdcard.h w25qxx.c w25qxx.h spi.c spi.h i2s.c i2s.h wm8978.c wm8978.h myiic.c myiic.h sram.c sram.h usart3.c usart3.h timer.c timer.h
  group MALLOC
    ./MALLOC/: malloc.c malloc.h
  group USMART
    ./USMART/: usmart.c usmart.h usmart_config.c usmart_str.c usmart_str.h
  group TEXT
    ./TEXT/: fontupd.c fontupd.h text.c text.h
  group APP
    ./APP/: audioplay.c audioplay.h
  group AUDIOCODEC
    ./AUDIOCODEC/: wavplay.c wavplay.h
  group XMRAM
    ./XMRAM/: XMRAM.h XMRAM.lib
  group ATK-RM04
    ./ATK-RM04/: common.c common.h wifiap.c wifista.c
software components: CMSIS:CORE 5.1.1, Device:STM32Cube HAL:ADC 1.7.13, Device:STM32Cube HAL:Common 1.7.13, Device:STM32Cube HAL:Cortex 1.7.13, Device:STM32Cube HAL:DAC 1.7.13, Device:STM32Cube HAL:DMA 1.7.13, Device:STM32Cube HAL:Flash 1.7.13, Device:STM32Cube HAL:GPIO 1.7.13, Device:STM32Cube HAL:I2S 1.7.13, Device:STM32Cube HAL:PWR 1.7.13, Device:STM32Cube HAL:RCC 1.7.13, Device:STM32Cube HAL:RTC 1.7.13, Device:STM32Cube HAL:SD 1.7.13, Device:STM32Cube HAL:SPI 1.7.13, Device:STM32Cube HAL:SRAM 1.7.13, Device:STM32Cube HAL:TIM 1.7.13, Device:STM32Cube HAL:UART 1.7.13, Device:STM32Cube HAL:USART 1.7.13, Device:Startup 2.6.3
